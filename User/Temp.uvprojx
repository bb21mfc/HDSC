# Keil uVision project Temp.uvprojx, settings and files
target HC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c include: ..\drive\inc;..\common;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\include;..\CMSIS;..\BSP\BSP_GPIO;..\BSP\BSP_UART;..\BSP\BSP_FIFO;..\APP\AT_CMD;..\BSP\BSP_PWR;..\APP\DEBUG
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group USER
    ../common/: main.c
  group COMMON
    ../common/: system_hc32f46x.c startup_hc32f46x.s
  group APP
    ../APP/AT_CMD/: at_cmd.c
    ../APP/DEBUG/: debug.c
  group BSP
    ../BSP/BSP_GPIO/: bsp_gpio.c
    ../BSP/BSP_UART/: bsp_uart.c
    ../BSP/BSP_FIFO/: fifo.c
    ../BSP/BSP_PWR/: bsp_pwr.c
  group DRIVE
    ../drive/src/: hc32f46x_clk.c hc32f46x_efm.c hc32f46x_icg.c hc32f46x_pwc.c hc32f46x_utility.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_usart.c
  group PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
